# Keil uVision project usb.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: usb +hex
  AfterMake: ./../output/Hex2bix.exe -i -f 0xC2 -o  ./../output/usb.iic ./../output/usb.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Inc;..\Lib;..\src
  group Source Group 1
    ../src/: fw.c periph.c dscr.a51
    ../Lib/: EZUSB.LIB USBJmpTb.OBJ
